# Keil uVision project Project.uvproj, settings and files
target STM32F429I-DISCO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=4 oTime=1 uC99=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base __KEIL__
  c misc: --diag_suppress 1293,83
  c include: ..\..\..\..\Libraries\ChibiOS_2.6.7\os\kernel\include;..\..\..\..\Libraries\ChibiOS_2.6.7\os\ports\common\ARMCMx;..\..\..\..\Libraries\ChibiOS_2.6.7\os\ports\common\ARMCMx\CMSIS\include;..\..\..\..\Libraries\ChibiOS_2.6.7\os\ports\RVCT\ARMCMx;..\..\..\..\Libraries\ChibiOS_2.6.7\os\ports\RVCT\ARMCMx\STM32F4xx;..\..\..\..\Libraries\ChibiOS_2.6.7\os\hal\include;..\..\..\..\Libraries\ChibiOS_2.6.7\os\hal\platforms\STM32;..\..\..\..\Libraries\ChibiOS_2.6.7\os\hal\platforms\STM32\GPIOv2;..\..\..\..\Libraries\ChibiOS_2.6.7\os\hal\platforms\STM32\OTGv1;..\..\..\..\Libraries\ChibiOS_2.6.7\os\hal\platforms\STM32F4xx;..\..\..\..\Libraries\ChibiOS_2.6.7\os\hal\platforms\STM32\SPIv1;..\..\..\..\Libraries\ChibiOS_2.6.7\os\hal\platforms\STM32\I2Cv1;..\..\..\..\Libraries\ChibiOS_2.6.7\os\various;..\..\..\..\Libraries\ugfx_release_22_150104;..\..\..\..\Libraries\ugfx_release_22_150104\boards\base\STM32F429i-Discovery;..\..\..\..\Libraries\ugfx_release_22_150104\drivers\gdisp\STM32F429iDiscovery;..\..\..\..\Libraries\ugfx_release_22_150104\src\gdisp\fonts;..\..\..\..\Libraries\ugfx_release_22_150104\src\gdisp\mcufont;..\;..\..\conf;..\..\..\..\Libraries\ChibiOS_2.6.7\test
  asm misc: --cpreproc
  asm include: ..\..\..\..\Libraries\ChibiOS_2.6.7\os\ports\RVCT\ARMCMx\STM32F4xx;..\..\conf
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x1
  group main
    ../: main.c
  group conf
    ../../conf/: board.c board.h chconf.h
    ../: halconf.h mcuconf.h gfxconf.h
  group os
    ../../../../Libraries/ChibiOS_2.6.7/os/kernel/src/: chlists.c chschd.c chsem.c chsys.c chthreads.c chvt.c chdynamic.c chheap.c chmemcore.c chcond.c chdebug.c chevents.c chmboxes.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c
    ../../../../Libraries/ChibiOS_2.6.7/os/various/: chprintf.c shell.c memstreams.c chrtclib.c evtimer.c
  group hal
    ../../../../Libraries/ChibiOS_2.6.7/os/hal/src/: hal.c pal.c usb.c serial_usb.c spi.c tm.c i2c.c
  group platform
    ../../../../Libraries/ChibiOS_2.6.7/os/hal/platforms/STM32F4xx/: hal_lld.c stm32_dma.c
    ../../../../Libraries/ChibiOS_2.6.7/os/hal/platforms/STM32/GPIOv2/: pal_lld.c
    ../../../../Libraries/ChibiOS_2.6.7/os/hal/platforms/STM32/OTGv1/: usb_lld.c
    ../../../../Libraries/ChibiOS_2.6.7/os/hal/templates/: uart_lld.c
    ../../../../Libraries/ChibiOS_2.6.7/os/hal/platforms/STM32/SPIv1/: spi_lld.c
    ../../../../Libraries/ChibiOS_2.6.7/os/hal/platforms/STM32/I2Cv1/: i2c_lld.c
  group port
    ../../../../Libraries/ChibiOS_2.6.7/os/ports/RVCT/ARMCMx/: chcore.c chcore_v7m.c cstartup.s chcoreasm_v7m.s
    ../../../../Libraries/ChibiOS_2.6.7/os/ports/RVCT/ARMCMx/STM32F4xx/: vectors.s
    ../../../../Libraries/ChibiOS_2.6.7/os/ports/common/ARMCMx/: nvic.c
  group gfx
    ../../../../Libraries/ugfx_release_22_150104/boards/base/STM32F429i-Discovery/: board_STM32F429iDiscovery.h stm32f4xx_fmc.c stm32f429i_discovery_sdram.c
    ../../../../Libraries/ugfx_release_22_150104/src/gdisp/: gdisp.c gdisp_fonts.c gdisp_image.c
    ../../../../Libraries/ugfx_release_22_150104/src/: gfx.c
    ../../../../Libraries/ugfx_release_22_150104/src/gos/: gos_chibios.c
    ../../../../Libraries/ugfx_release_22_150104/drivers/gdisp/STM32F429iDiscovery/: gdisp_lld_STM32F429iDiscovery.c
    ../../../../Libraries/ugfx_release_22_150104/src/gdriver/: gdriver.c
    ../../../../Libraries/ugfx_release_22_150104/src/gdisp/mcufont/: mf_font.c mf_justify.c mf_rlefont.c mf_scaledfont.c mf_bwfont.c mf_encoding.c mf_wordwrap.c
    ../../../../Libraries/ugfx_release_22_150104/src/gevent/: gevent.c
    ../../../../Libraries/ugfx_release_22_150104/src/ginput/: ginput.c ginput_mouse.c
    ../../../../Libraries/ugfx_release_22_150104/src/gwin/: gwin.c gwin_console.c gwin_wm.c gwin_graph.c gwin_widget.c gwin_button.c
    ../../../../Libraries/ugfx_release_22_150104/src/gtimer/: gtimer.c
    ../../../../Libraries/ugfx_release_22_150104/drivers/ginput/touch/STMPE811/: gmouse_lld_STMPE811.c
    ../../../../Libraries/ugfx_release_22_150104/src/gqueue/: gqueue.c
