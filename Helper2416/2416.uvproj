# Keil uVision project 2416.uvproj, settings and files
target 2416 (ARM-ADS)
  device: S3C2416 Samsung
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0x00000000-0x00007FFF) CPUTYPE(ARM926EJ-S)
  output: 2416 +hex
  AfterMake: fromelf.exe  --bin .\obj\output\2416.axf -o .\output\2416.bin
  c flags: Optim=3
  c misc: --c99
  c include: .\raw-os\include;.\port;.\raw-os\extension\include;.\bsp\include;.\LwIP;.\LwIP\include\arch;.\LwIP\include\lwip;.\LwIP\include\ipv4;.\LwIP\include;.\fatfs;.\uCGUI\Config;.\uCGUI\GUI_Source\AntiAlias;.\uCGUI\GUI_Source\ConvertColor;.\uCGUI\GUI_Source\ConvertMono;.\uCGUI\GUI_Source\Core;.\uCGUI\GUI_Source\Font;.\uCGUI\GUI_Source\JPEG;.\uCGUI\GUI_Source\LCDDriver;.\uCGUI\GUI_Source\MemDev;.\uCGUI\GUI_Source\MultiLayer;.\uCGUI\GUI_Source\Widget;.\uCGUI\GUI_Source\WM;.\uCGUI\GUI_X;.\uCGUI\GUIDemo;.\bsp\NandFlash;.\yaffs2;.\yaffs2\direct;.\yaffs2\direct\test-framework;.\system;.\ugfx;.\ugfx\src\gadc;.\ugfx\src\gaudio;.\ugfx\src\gdisp\mcufont;.\ugfx\src\gevent;.\ugfx\src\gfile;.\ugfx\src\ginput;.\ugfx\src\gmisc;.\ugfx\src\gqueue;.\ugfx\src\gtimer;.\ugfx\src\gwin;.\ugfx\src\gos;.\ugfx\drivers\gdisp\framebuffer;.\\ugfx\drivers\ginput\touch\helper2416;.\ugfx\boards\base\helper2416;.\ugfx\app;.\test\netio;.\test\lua_efficiency;.\lua\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x10000
  scatter file: .\system\2416.sct
  group kernel
    ./raw-os/: raw-os.c
  group port
    ./port/: port.c port_hook.c cpu.s
  group system
    ./system/: irq.c start.S 2416_lib.S mmu.c user_extension.c
  group test
    ./test/: main.c shell_task.c cmd.c lwip_ping_test.c ping.c tftp_test.c tcp_server.c udp_client.c udp_server.c tcp_client.c fatfs_test.c yaffs_test.c reboot.c usbd_test.c wav_test.c ugfx_test.c task_stack_detect.c
    ./tftp_client/: client.c
    ./uCGUI/GUI/: WIDGET_FrameWin.c 2DGL_DrawGIF.c TOUCH_Sample.c
    ./output/: successwave.c r1wave.c
    ./test/netio/: netio.c
    ./test/lua_efficiency/: lua_efficiency.c
  group kernel_extension
    ./raw-os/extension/lib/: string.c fifo.c raw_mlock.c raw_work_queue.c
    ./raw-os/extension/shell/: rsh.c
    ./raw-os/extension/mm/: raw_malloc.c raw_page.c
  group bsp
    ./bsp/: uart.c clk_get.c timer.c iic.c watchdog.c pwm.c smc.c lan9220_process.c spinorflash.c hs1_mmc.c ucgui_test.c lcd_driver.c app_api.c bsp_init.c ADCTs_driver.c timer4.c
    ./system/: yaffs.lib usbd.lib i2sdma.lib
  group LwIP
    ./LwIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./LwIP/arch/: sys_arch.c
    ./LwIP/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./LwIP/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./LwIP/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ./LwIP/netif/: etharp.c ethernetif.c slipif.c
    ./LwIP/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group fatfs
    ./fatfs/: diskio.c ff.c
    ./fatfs/option/: syscall.c unicode.c
  group GUI_AntiAlias
    ./uCGUI/GUI_Source/AntiAlias/: GUIAAArc.c GUIAAChar.c GUIAAChar2.c GUIAAChar4.c GUIAACircle.c GUIAALib.c GUIAALine.c GUIAAPoly.c GUIAAPolyOut.c
  group GUI_ConvertColor
    ./uCGUI/GUI_Source/ConvertColor/: LCDP111.c LCDP222.c LCDP233.c LCDP323.c LCDP332.c LCDP444_12.c LCDP444_12_1.c LCDP444_16.c LCDP555.c LCDP556.c LCDP565.c LCDP655.c LCDP8666.c LCDP8666_1.c LCDPM233.c LCDPM323.c LCDPM332.c LCDPM444_12.c LCDPM444_16.c LCDPM555.c LCDPM556.c LCDPM565.c LCDPM655.c LCDP666.c LCDP888.c LCDPM666.c LCDPM888.c
  group GUI_ConvertMono
    ./uCGUI/GUI_Source/ConvertMono/: LCDP0.c LCDP2.c LCDP4.c
  group GUI_Core
    ./uCGUI/GUI_Source/Core/: GUI__AddSpaceHex.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectMax.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawHLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_RectsIntersect.c GUI_SaveContext.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUI2DLib.c GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIUC0.c GUIVal.c GUIValf.c LCD.c LCD_API.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDPM565_Index2Color.c LCDRLE4.c LCDRLE8.c GUI__GetCursorPos.c GUI__Arabic.c GUI__DrawBitmap16bpp.c GUI_DispStringInRectWrap.c GUI_DrawBitmap_555.c GUI_DrawBitmap_565.c GUI_DrawBitmap_888.c GUI_DrawGraphEx.c GUI_DrawLine.c GUI_DrawPoint.c GUI_DrawPolygon.c GUI_GetDrawMode.c GUI_GetOrg.c GUI_GIF.c GUI_ScreenSize.c GUI_SetClipRect.c GUI_UC_ConvertUC2UTF8.c GUI_UC_ConvertUTF82UC.c LCD_ReadRect.c LCDP888_Index2Color.c LCDPM888_Index2Color.c LCDRLE16.c
  group GUI_Font
    ./uCGUI/GUI_Source/Font/: F4x6.c F6x8.c F08_1.c F08_ASCII.c F8x8.c F8x10_ASCII.c F8x12_ASCII.c F8x13_1.c F8x13_ASCII.c F8x15B_1.c F8x15B_ASCII.c F8x16.c F10_1.c F10_ASCII.c F10S_1.c F10S_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F13H_1.c F13H_ASCII.c F13HB_1.c F13HB_ASCII.c F16_1.c F16_1HK.c F16_ASCII.c F16_HK.c F16B_1.c F16B_ASCII.c F24_1.c F24_ASCII.c F24B_1.c F24B_ASCII.c F32_1.c F32_ASCII.c F32B_1.c F32B_ASCII.c FComic18B_1.c FComic18B_ASCII.c FComic24B_1.c FComic24B_ASCII.c FD24x32.c FD32.c FD36x48.c FD48.c FD48x64.c FD60x80.c FD64.c FD80.c
  group GUI_LCDDriver
    ./uCGUI/GUI_Source/LCDDriver/: LCDDummy.c
  group GUI_MemDev
    ./uCGUI/GUI_Source/MemDev/: GUIDEV.c GUIDEV_1.c GUIDEV_8.c GUIDEV_16.c GUIDEV_AA.c GUIDEV_Auto.c GUIDEV_Banding.c GUIDEV_Clear.c GUIDEV_CmpWithLCD.c GUIDEV_CopyFromLCD.c GUIDEV_CreateFixed.c GUIDEV_GetDataPtr.c GUIDEV_GetXSize.c GUIDEV_GetYSize.c GUIDEV_Measure.c GUIDEV_ReduceYSize.c GUIDEV_SetOrg.c GUIDEV_Usage.c GUIDEV_UsageBM.c GUIDEV_Write.c GUIDEV_WriteAlpha.c GUIDEV_WriteEx.c GUIDEV_XY2PTR.c
  group GUI_MultiLayer
    ./uCGUI/GUI_Source/MultiLayer/: LCD_1.c LCD_2.c LCD_3.c LCD_4.c
  group GUI_Widget
    ./uCGUI/GUI_Source/Widget/: BUTTON__SetBitmapObj.c BUTTON_Bitmap.c BUTTON_BMP.c BUTTON_Create.c BUTTON_CreateIndirect.c BUTTON_Default.c BUTTON_Get.c BUTTON_IsPressed.c BUTTON_SelfDraw.c BUTTON_SetTextAlign.c BUTTON_StreamedBitmap.c CHECKBOX_Create.c CHECKBOX_CreateIndirect.c CHECKBOX_Default.c CHECKBOX_GetState.c CHECKBOX_Image.c CHECKBOX_IsChecked.c CHECKBOX_SetBkColor.c CHECKBOX_SetDefaultImage.c CHECKBOX_SetFont.c CHECKBOX_SetImage.c CHECKBOX_SetNumStates.c CHECKBOX_SetSpacing.c CHECKBOX_SetState.c CHECKBOX_SetText.c CHECKBOX_SetTextAlign.c CHECKBOX_SetTextColor.c DIALOG.c DROPDOWN.c DROPDOWN_Create.c DROPDOWN_CreateIndirect.c DROPDOWN_DeleteItem.c DROPDOWN_InsertString.c DROPDOWN_ItemSpacing.c DROPDOWN_SetAutoScroll.c DROPDOWN_SetTextAlign.c DROPDOWN_SetTextHeight.c EDIT.c EDIT_Create.c EDIT_CreateIndirect.c EDIT_Default.c EDIT_GetNumChars.c EDIT_SetCursorAtChar.c EDIT_SetInsertMode.c EDIT_SetpfAddKeyEx.c EDIT_SetpfUpdateBuffer.c EDIT_SetSel.c EDITBin.c EDITDec.c EDITFloat.c EDITHex.c FRAMEWIN.c FRAMEWIN__UpdateButtons.c FRAMEWIN_AddMenu.c FRAMEWIN_Button.c FRAMEWIN_ButtonClose.c FRAMEWIN_ButtonMax.c FRAMEWIN_ButtonMin.c FRAMEWIN_Create.c FRAMEWIN_CreateIndirect.c FRAMEWIN_Default.c FRAMEWIN_Get.c FRAMEWIN_IsMinMax.c FRAMEWIN_MinMaxRest.c FRAMEWIN_SetBorderSize.c FRAMEWIN_SetColors.c FRAMEWIN_SetFont.c FRAMEWIN_SetResizeable.c FRAMEWIN_SetTitleHeight.c FRAMEWIN_SetTitleVis.c GUI_ARRAY.c GUI_ARRAY_DeleteItem.c GUI_ARRAY_InsertItem.c GUI_ARRAY_ResizeItem.c GUI_DRAW.c GUI_DRAW_BITMAP.c GUI_DRAW_BMP.c GUI_DRAW_Self.c GUI_DRAW_STREAMED.c GUI_EditBin.c GUI_EditDec.c GUI_EditFloat.c GUI_EditHex.c GUI_EditString.c GUI_HOOK.c HEADER.c HEADER__SetDrawObj.c HEADER_Bitmap.c HEADER_BMP.c HEADER_Create.c HEADER_CreateIndirect.c HEADER_StreamedBitmap.c LISTBOX.c LISTBOX_Create.c LISTBOX_CreateIndirect.c LISTBOX_Default.c LISTBOX_DeleteItem.c LISTBOX_Font.c LISTBOX_GetItemText.c LISTBOX_GetNumItems.c LISTBOX_InsertString.c LISTBOX_ItemDisabled.c LISTBOX_ItemSpacing.c LISTBOX_MultiSel.c LISTBOX_ScrollStep.c LISTBOX_SetAutoScroll.c LISTBOX_SetBkColor.c LISTBOX_SetOwner.c LISTBOX_SetOwnerDraw.c LISTBOX_SetScrollbarWidth.c LISTBOX_SetString.c LISTBOX_SetTextColor.c LISTVIEW.c LISTVIEW_Create.c LISTVIEW_CreateIndirect.c LISTVIEW_Default.c LISTVIEW_DeleteColumn.c LISTVIEW_DeleteRow.c LISTVIEW_GetBkColor.c LISTVIEW_GetFont.c LISTVIEW_GetHeader.c LISTVIEW_GetNumColumns.c LISTVIEW_GetNumRows.c LISTVIEW_GetSel.c LISTVIEW_GetTextColor.c LISTVIEW_SetBkColor.c LISTVIEW_SetColumnWidth.c LISTVIEW_SetFont.c LISTVIEW_SetGridVis.c LISTVIEW_SetItemColor.c LISTVIEW_SetItemText.c LISTVIEW_SetLBorder.c LISTVIEW_SetRBorder.c LISTVIEW_SetRowHeight.c LISTVIEW_SetSel.c LISTVIEW_SetTextAlign.c LISTVIEW_SetTextColor.c MENU.c MENU__FindItem.c MENU_Attach.c MENU_CreateIndirect.c MENU_Default.c MENU_DeleteItem.c MENU_DisableItem.c MENU_EnableItem.c MENU_GetItem.c MENU_GetItemText.c MENU_GetNumItems.c MENU_InsertItem.c MENU_Popup.c MENU_SetBkColor.c MENU_SetBorderSize.c MENU_SetFont.c MENU_SetItem.c MENU_SetTextColor.c MESSAGEBOX.c MULTIEDIT.c MULTIEDIT_Create.c MULTIEDIT_CreateIndirect.c MULTIPAGE.c MULTIPAGE_Create.c MULTIPAGE_CreateIndirect.c MULTIPAGE_Default.c PROGBAR.c PROGBAR_Create.c PROGBAR_CreateIndirect.c RADIO_Create.c RADIO_CreateIndirect.c RADIO_Default.c RADIO_Image.c RADIO_SetBkColor.c RADIO_SetDefaultImage.c RADIO_SetFont.c RADIO_SetGroupId.c RADIO_SetImage.c RADIO_SetText.c RADIO_SetTextColor.c SCROLLBAR.c SCROLLBAR_Create.c SCROLLBAR_CreateIndirect.c SCROLLBAR_Defaults.c SCROLLBAR_GetValue.c SCROLLBAR_SetWidth.c SLIDER_Create.c SLIDER_CreateIndirect.c TEXT.c TEXT_Create.c TEXT_CreateIndirect.c TEXT_SetBkColor.c TEXT_SetFont.c TEXT_SetText.c TEXT_SetTextAlign.c TEXT_SetTextColor.c WIDGET.c WIDGET_Effect_3D.c WIDGET_Effect_3D1L.c WIDGET_Effect_3D2L.c WIDGET_Effect_None.c WIDGET_Effect_Simple.c WIDGET_FillStringInRect.c WIDGET_SetEffect.c WIDGET_SetWidth.c WINDOW.c WINDOW_Default.c BUTTON_GetBitmap.c BUTTON_SetFocusColor.c CHECKBOX_GetText.c CHECKBOX_SetBoxBkColor.c CHECKBOX_SetFocusColor.c DROPDOWN_AddString.c DROPDOWN_Default.c DROPDOWN_GetNumItems.c DROPDOWN_SetBkColor.c DROPDOWN_SetColor.c DROPDOWN_SetFont.c DROPDOWN_SetScrollbarColor.c DROPDOWN_SetScrollbarWidth.c DROPDOWN_SetTextColor.c EDIT_GetCursorPixelPos.c EDIT_GetCursorPos.c EDIT_SetFocussable.c EDIT_SetTextMode.c EDITUlong.c GRAPH_CreateIndirect.c GRAPH_DATA_XY.c GRAPH_DATA_YT.c GRAPH_SCALE.c HEADER_GetSel.c HEADER_SetDragLimit.c LISTBOX_GetTextAlign.c LISTBOX_SetScrollbarColor.c LISTBOX_SetTextAlign.c LISTVIEW_DeleteAllRows.c LISTVIEW_DisableRow.c LISTVIEW_GetItemText.c LISTVIEW_InsertRow.c LISTVIEW_SetAutoScroll.c LISTVIEW_SetSort.c LISTVIEW_UserData.c PROGBAR_SetBarColor.c PROGBAR_SetFont.c PROGBAR_SetMinMax.c PROGBAR_SetText.c PROGBAR_SetTextAlign.c PROGBAR_SetTextColor.c PROGBAR_SetTextPos.c RADIO_GetText.c RADIO_SetFocusColor.c SCROLLBAR_SetColor.c SLIDER_Default.c SLIDER_SetFocusColor.c TEXT_Default.c TEXT_SetWrapMode.c BUTTON1.c CHECKBOX1.c GRAPH1.c RADIO1.c SLIDER1.c
  group GUI_WM
    ./uCGUI/GUI_Source/WM/: WM.c WM__ForEachDesc.c WM__GetFirstSibling.c WM__GetFocussedChild.c WM__GetLastSibling.c WM__GetOrg_AA.c WM__GetPrevSibling.c WM__IsAncestor.c WM__IsChild.c WM__IsEnabled.c WM__NotifyVisChanged.c WM__Screen2Client.c WM__SendMessage.c WM__SendMessageIfEnabled.c WM__SendMessageNoPara.c WM__UpdateChildPositions.c WM_AttachWindow.c WM_BringToBottom.c WM_BringToTop.c WM_Broadcast.c WM_CheckScrollPos.c WM_CriticalHandle.c WM_DIAG.c WM_EnableWindow.c WM_ForEachDesc.c WM_GetBkColor.c WM_GetClientRect.c WM_GetClientWindow.c WM_GetDesktopWindow.c WM_GetDesktopWindowEx.c WM_GetDiagInfo.c WM_GetDialogItem.c WM_GetFirstChild.c WM_GetFlags.c WM_GetFocussedWindow.c WM_GetId.c WM_GetInsideRect.c WM_GetInsideRectExScrollbar.c WM_GetInvalidRect.c WM_GetNextSibling.c WM_GetOrg.c WM_GetParent.c WM_GetPrevSibling.c WM_GetScrollbar.c WM_GetScrollPartner.c WM_GetScrollState.c WM_GetWindowRect.c WM_GetWindowSize.c WM_HasCaptured.c WM_HasFocus.c WM_Hide.c WM_IsCompletelyVisible.c WM_IsEnabled.c WM_IsFocussable.c WM_IsVisible.c WM_IsWindow.c WM_MakeModal.c WM_Move.c WM_MoveChildTo.c WM_NotifyParent.c WM_OnKey.c WM_Paint.c WM_PID__GetPrevState.c WM_ResizeWindow.c WM_Screen2Win.c WM_SendMessageNoPara.c WM_SendToParent.c WM_SetAnchor.c WM_SetCallback.c WM_SetCapture.c WM_SetCaptureMove.c WM_SetCreateFlags.c WM_SetDesktopColor.c WM_SetFocus.c WM_SetFocusOnNextChild.c WM_SetFocusOnPrevChild.c WM_SetId.c WM_SetpfPollPID.c WM_SetScrollbar.c WM_SetScrollState.c WM_SetSize.c WM_SetTrans.c WM_SetTransState.c WM_SetUserClipRect.c WM_SetXSize.c WM_SetYSize.c WM_Show.c WM_StayOnTop.c WM_Timer.c WM_TimerExternal.c WM_UserData.c WM_Validate.c WM_ValidateWindow.c WMMemDev.c WMTouch.c WM_GetCallback.c WM_GetScrollPos.c WM_InvalidateArea.c WM_PaintWindowAndDescs.c WM_SetScrollPos.c WM_SetWindowPos.c WM_SIM.c WM_UpdateWindowAndDescs.c
  group GUI_X
    ./uCGUI/GUI_X/: GUI_RAW_OS.c GUI_RAWOS_Touch.c
  group GUI_demo
    ./uCGUI/GUIDemo/: SeggerLogoBlue.c GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap4bpp.c GUIDEMO_Bitmap.c GUIDEMO_Circle.c GUIDEMO_ColorBar.c GUIDEMO_ColorList.c GUIDEMO_Cursor.c GUIDEMO_Dialog.c GUIDEMO_Font.c GUIDEMO_FrameWin.c GUIDEMO_Graph.c GUIDEMO_HardwareInfo.c GUIDEMO_Intro.c GUIDEMO_LUT.c GUIDEMO_MemDevB.c GUIDEMO_Messagebox.c GUIDEMO_Navi.c GUIDEMO_Polygon.c GUIDEMO_ProgBar.c GUIDEMO_Speed.c GUIDEMO_Touch.c GUIDEMO_WM.c MainTask.c MicriumLogo.c MicriumLogoWRed.c
  group font
    ./uCGUI/font/: SimSun_20.c SimSun_13.c SimSun_17.c
  group ugfx
    ./ugfx/app/: guiapp.c
    ./ugfx/drivers/gdisp/framebuffer/: gdisp_lld_framebuffer.c
    ./ugfx/drivers/ginput/touch/helper2416/: ginput_lld_mouse.c
    ./ugfx/src/gos/: rawrtos.c
  group ugfxport
    ./ugfx/src/gadc/: gadc.c
    ./ugfx/src/gaudio/: gaudio.c
    ./ugfx/src/gdisp/: fonts.c gdisp.c image.c image_bmp.c image_gif.c image_jpg.c image_native.c image_png.c
    ./ugfx/src/gdisp/mcufont/: mf_bwfont.c mf_encoding.c mf_font.c mf_justify.c mf_kerning.c mf_rlefont.c mf_scaledfont.c mf_wordwrap.c
    ./ugfx/src/gevent/: gevent.c
    ./ugfx/src/gfile/: gfile.c
    ./ugfx/src/ginput/: dial.c ginput.c keyboard.c mouse.c toggle.c
    ./ugfx/src/gmisc/: arrayops.c gmisc.c trig.c
    ./ugfx/src/gqueue/: gqueue.c
    ./ugfx/src/gtimer/: gtimer.c
    ./ugfx/src/gwin/: button.c checkbox.c console.c frame.c gcontainer.c gimage.c graph.c gwidget.c gwin.c gwm.c label.c list.c progressbar.c radio.c slider.c
    ./ugfx/src/: gfx.c
  group lua
    ./lua/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c luac.c lundump.c lvm.c lzio.c
